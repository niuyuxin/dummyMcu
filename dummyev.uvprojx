# Keil uVision project dummyev.uvprojx, settings and files
target dummyev (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1778 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dummyev +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Drivers\include;.\FrameWork\inc;.\UserCode\inc;.\Core\CM3\CoreSupport;.\Core\CM3\DeviceSupport\NXP\LPC177x_8x;.\Drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Core
    ./Core/CM3/CoreSupport/: core_cm3.c
    ./Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
    ./Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group Drivers
    ./Drivers/source/: debug_frmwrk.c lpc177x_8x_adc.c lpc177x_8x_can.c lpc177x_8x_clkpwr.c lpc177x_8x_crc.c lpc177x_8x_dac.c lpc177x_8x_emc.c lpc177x_8x_exti.c lpc177x_8x_gpdma.c lpc177x_8x_gpio.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_mci.c lpc177x_8x_mcpwm.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_pwm.c lpc177x_8x_qei.c lpc177x_8x_rtc.c lpc177x_8x_ssp.c lpc177x_8x_systick.c lpc177x_8x_timer.c lpc177x_8x_uart.c lpc177x_8x_wwdt.c
  group FrameWork
    ./FrameWork/src/: FRAMEWORK.C
  group UserCode
    ./UserCode/src/: debuguart.c dummyev.c main.c uart2_nCCS.c Uart03_timer0_init.c
